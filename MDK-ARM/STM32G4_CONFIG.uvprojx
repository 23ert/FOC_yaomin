# Keil uVision project STM32G4_CONFIG.uvprojx, settings and files
target STM32G4_CONFIG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G4_CONFIG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\Board;..\Core\Src;..\FUNC;..\MATLAB;..\Middlewares\ST\ARM\DSP\Inc;..\Middlewares\ST\ARM\DSP\Lib;..\FUNC\HMI;..\FUNC\SpeedCtrl;..\FUNC\VF;..\FUNC\SguanFOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c adc.c opamp.c tim.c comp.c dac.c
    ../Core/Inc/: tim.h comp.h dac.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Board
    ../Board/: board.c board.h sample_Init.c sample_Init.h device.h fault_handler.c fault_handler.h
  group FUNC
    ../FUNC/: func_main.c func_main.h MT.c MT.h
    ../FUNC/HMI/: USART_VOFT.c USART_VOFT.h
  group MATLAB
    ../MATLAB/: Clark_test.c Clark_test.h mw_cmsis.h rtwtypes.h
  group Middlewares
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
  group FUNC/VF
    ../FUNC/VF/: myVF.c myVF.h
  group FUNC/SguanFOC
    ../FUNC/SguanFOC/: Sguan_Config.h Sguan_IQmath.h Sguan_math.c Sguan_math.h Sguan_MotorStatus.c Sguan_MotorStatus.h Sguan_printf.c Sguan_printf.h SguanFOC.c SguanFOC.h UserData_Config.h UserData_UserControl.h UserData_Status.h UserData_Motor.h UserData_Function.h Sguan_Cogging.c Sguan_Cogging.h Sguan_DOB.c Sguan_DOB.h Sguan_Feedforward.c Sguan_Feedforward.h Sguan_Filter.c Sguan_Filter.h Sguan_Hall.c Sguan_Hall.h Sguan_HFI.c Sguan_HFI.h Sguan_Identify.c Sguan_Identify.h Sguan_IQmath.c Sguan_Ladrc.c Sguan_Ladrc.h Sguan_LTD.c Sguan_LTD.h Sguan_NLFO.c Sguan_NLFO.h Sguan_NSD.c Sguan_NSD.h Sguan_Optimize.c Sguan_Optimize.h Sguan_PID.c Sguan_PID.h Sguan_PLL.c Sguan_PLL.h Sguan_SMC.c Sguan_SMC.h Sguan_SMO.c Sguan_SMO.h Sguan_SPWM.c Sguan_SPWM.h Sguan_STA.c Sguan_STA.h Sguan_SVPWM.c Sguan_SVPWM.h UserData_Parameter.h
software components: CMSIS:CORE 4.3.0
